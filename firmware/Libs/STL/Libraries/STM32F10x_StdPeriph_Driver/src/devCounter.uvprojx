# Keil uVision project devCounter.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: devCounter +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\..\Keil\standartLibs\CMSIS\Inc;..\..\..\..\..\Keil\standartLibs\CMSIS\Src;..\..\..\..\..\Keil\standartLibs\STL\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Keil\standartLibs\STL\Libraries\STM32F10x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: main.c
